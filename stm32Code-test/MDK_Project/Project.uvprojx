# Keil uVision project Project.uvprojx, settings and files
target Projet (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=1
  c include: ..\MDK_APP;..\MDK_Core;..\MDK_Hardware;..\MDK_Hardware\OLED;..\MDK_STM32F10x_FWLib\inc;..\MDK_System;..\MDK_User
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../MDK_Core/: startup_stm32f10x_ld.s
  group MDK_Core
    ../MDK_Core/: core_cm3.c
  group MDK_FWlib
    ../MDK_STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group MDK_User
    ../MDK_User/: main.c stm32f10x_it.c system_stm32f10x.c
  group MDK_Hardware
    ../MDK_Hardware/OLED/: oled_drive.c oled_show.c oled_ShowDrive.c oled_IndexCtr.c
    ../MDK_Hardware/: bsp_beep.c bsp_Key.c bsp_led.c bsp_esp01s.c ds18b20.c
  group MDK_System
    ../MDK_System/: bsp_adc.c iwdg.c sys.c systick_delay.c usart_use1.c
  group MDK_APP
    ../MDK_APP/: GeneralTIM.c MyTypedef.c TimingSet.c
