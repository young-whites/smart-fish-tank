# Keil uVision project Project.uvprojx, settings and files
target Projet (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x00008000) IRAM(0x20000000,0x00002800) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: STM32F10X_LD,USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=1
  c include: ..\MDK_APP;..\MDK_Core;..\MDK_Hardware\led;..\MDK_STM32F10x_FWLib\inc;..\MDK_System\dwt_delay;..\MDK_System\sys;..\MDK_User;..\MDK_System\systick_delay;..\MDK_System\rx_data_queque;..\MDK_System\systick_delay;..\MDK_System\usart;..\MDK_Hardware\Beep;..\MDK_Hardware\Bluetooth;..\MDK_Hardware\Solenoid valve;..\MDK_Hardware\Key;..\MDK_Hardware\Peristaltic pump;..\MDK_Hardware\Compressor;..\MDK_Hardware\Fan;..\MDK_Hardware\WF100DPZ5BGS6DT;..\MDK_System\iic;..\MDK_Hardware\TK1300F;..\MDK_System\oldDemo;..\MDK_Hardware\WaterLevel;..\MDK_Hardware\OLED;..\MDK_Hardware\DHT11;..\MDK_Hardware\ESP01;..\MDK_Hardware\Fan;..\MDK_Hardware\MQ-2;..\MDK_Hardware\FireCheck;..\MDK_System\adc;..\MDK_System\iwdg;..\MDK_Hardware\DS18B20;..\MDK_Hardware\Servo;..\MDK_Hardware\Relay;..\MDK_Hardware\ESP01S
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group STARTUP
    ../MDK_Core/: startup_stm32f10x_ld.s
  group MDK_Core
    ../MDK_Core/: core_cm3.c
  group MDK_FWlib
    ../MDK_STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group MDK_User
    ../MDK_User/: main.c stm32f10x_it.c system_stm32f10x.c
  group MDK_Hardware
    ../MDK_Hardware/led/: bsp_led.c
    ../MDK_Hardware/Beep/: bsp_beep.c
    ../MDK_Hardware/Key/: bsp_Key.c
    ../MDK_Hardware/OLED/: oled_drive.c oled_show.c oled_ShowDrive.c
    ../MDK_Hardware/DS18B20/: bsp_ds18b20.c
    ../MDK_Hardware/Servo/: bsp_servo.c
    ../MDK_Hardware/Relay/: bsp_relay.c
    ../MDK_Hardware/ESP01S/: bsp_esp01s.c
  group MDK_System
    ../MDK_System/sys/: sys.c sys_status.c
    ../MDK_System/systick_delay/: systick_delay.c
    ../MDK_System/adc/: bsp_adc.c
    ../MDK_System/iwdg/: iwdg.c
    ../MDK_System/usart/: usart_use1.c
  group MDK_APP
    ../MDK_APP/: GeneralTIM.c TimingSet.c MyTypedef.c
